Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: dce1be83-c22b-4976-bcac-a30571de3bca, NumberOfSaves: 1]
File name: 0001
Time: 2025-02-27T12:56:19+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11503540_USA_F2662Vi:37266201_USA_11503540_F2662Vi, (2)
In: Default
Type - Material: z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Zinc_Steel, z_Miele_Design_GRGR, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 603 mm; Height: 2125 mm; Depth: 608 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 37266201_USA_11503540_F2662Vi; sets with these values: 2

# IfcDistributionPort, Port_358389_1
Description: Flow; FlowDirection: SOURCEANDSINK
